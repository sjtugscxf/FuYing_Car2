# IAR project Backup (2) of framework2016_K60.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: LPLD_K60
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: framework2016_K60.srec
  ILINK.IlinkOutputFile: framework2016_K60.out
configuration FLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.CoreVariant: 39
  ICCARM.CCIncludePath2: source; common; LPLD; LPLD\HW; LPLD\DEV; F:\IAR Systems\Embedded Workbench 7.0\arm\CMSIS
  AARM.AUserIncludes: F:\IAR Systems\Embedded Workbench 7.0\arm\CMSIS
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration BOOT (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: framework2016_K60.bin
  group app
    source/: Cam.c Cam.h CCD.c CCD.h framework2016.c HMI.c HMI.h Mag.c Mag.h Motor.c Motor.h OLED.c OLED.h OLED_UI.c OLED_UI.h PIT.c PIT.h UART.c UART.h UI_Operation.c UI_Operation.h Wave.c Wave.h
    LPLD/DEV/: Setting.h
  group lib/common
    common/: common.h MK60DZ10.h relocate.c relocate.h startup_K60.s system_MK60DZ10.c system_MK60DZ10.h
    source/: includes.h k60_card.h typedef.h
  group lib/LPLD
    LPLD/DEV/: DEV_MMA8451.c DEV_MMA8451.h
    LPLD/HW/: HW_I2C.c HW_I2C.h HW_MCG.c HW_MCG.h
    LPLD/: LPLD_Drivers.h
